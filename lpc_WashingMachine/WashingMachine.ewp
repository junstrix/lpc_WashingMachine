# IAR project WashingMachine.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC11C14 NXP LPC11C14
  ICCARM.CCIncludePath2: D:\tmp\arm\Common\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: WashingMachine.srec
  ILINK.IlinkOutputFile: WashingMachine.out
  ILINK.IlinkIcfFile: D:\tmp\arm\Common\icf\LPC1114_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group API
    D:/tmp/arm/Common/src/: clkconfig.c core_cm0.c cstartup_M.s gpio.c system_LPC11xx.c timer32.c uart.c
  group Header
    D:/tmp/arm/Common/inc/: stepmotor.h
    ./: washingMachine.h
  group SRC
    ./: main.c stepmotor.c washingMachine.c
